# IAR project Lab07IntegerFunctionStraightLine.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 TexasInstruments LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\LM3S811\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lab07IntegerFunctionStraightLine.out
  ILINK.IlinkAdditionalLibs: ..\LM3S811\Debug\Exe\LM3S811drivers.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    ./: absval.c absval.s disc.c disc.s main4absval.c main4disc.c
